## kernel/Kconfig.hz
```kconfig
#
# Timer Interrupt Frequency Configuration
#

config HZ
	int "muh hz"
	default 600
config SCHED_HRTICK
	def_bool HIGH_RES_TIMERS
```
